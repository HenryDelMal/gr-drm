options:
  parameters:
    author: HenrydelMal
    category: '[DRM Examples]'
    comment: Route the output to a virtual audio cable or line output. Keep speaker volume low.
    description: Continuously encodes a 1 kHz audio programme into DRM and emits a real 48 kHz baseband signal through the default sound-card sink.
    gen_cmake: 'Off'
    generate_options: qt_gui
    id: drm_live_soundcard
    output_language: python
    title: DRM Live Sound-card Baseband
  states: {}

blocks:
- name: tp
  id: variable_drm_config
  parameters:
    RM: '1'
    SO: '3'
    audio_sample_rate: '24000'
    long_interl: 'False'
    msc_mapping: '1'
    msc_prot_level_2_16: '1'
    msc_prot_level_2_64: '0'
    sdc_mapping: '1'
    station_label: '"gr-drm Live"'
    text_message: '"GNU Radio DRM sound-card baseband"'
  states: {}
- name: programme_tone
  id: analog_sig_source_x
  parameters:
    amp: '0.05'
    comment: Deterministic audio programme source; replace with Audio Source for a microphone or loopback device.
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: '24000'
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: pcm_scale
  id: blocks_multiply_const_vxx
  parameters:
    comment: Scale normalized audio for the FAAC float PCM interface used by gr-drm.
    const: '32768.0'
    type: float
  states: {}
- name: audio_encoder
  id: drm_audio_encoder_sb
  parameters:
    len_out: tp.msc().L_MUX()
    tp: tp
  states: {}
- name: msc_scrambler
  id: drm_scrambler_bb
  parameters:
    block_len: tp.msc().L_MUX()
  states: {}
- name: msc_mlc
  id: mlc_bc
  parameters:
    channel_type: '"MSC"'
    tp: tp
  states: {}
- name: msc_interleaver
  id: drm_interleaver_cc
  parameters:
    depth: drm.INTL_DEPTH_DRM
    interl_seq: tp.msc().cell_interl_seq()
    long_interl: tp.cfg().long_interl()
  states: {}
- name: fac_generator
  id: drm_generate_fac_b
  parameters:
    tp: tp
  states: {}
- name: fac_scrambler
  id: drm_scrambler_bb
  parameters:
    block_len: tp.fac().L()
  states: {}
- name: fac_mlc
  id: mlc_bc
  parameters:
    channel_type: '"FAC"'
    tp: tp
  states: {}
- name: sdc_generator
  id: drm_generate_sdc_b
  parameters:
    tp: tp
  states: {}
- name: sdc_scrambler
  id: drm_scrambler_bb
  parameters:
    block_len: tp.sdc().L()
  states: {}
- name: sdc_mlc
  id: mlc_bc
  parameters:
    channel_type: '"SDC"'
    tp: tp
  states: {}
- name: cell_mapper
  id: cell_mapping_cc
  parameters:
    tp: tp
  states: {}
- name: ifft
  id: fft_vxx
  parameters:
    comment: Convert mapped DRM carriers to time-domain OFDM symbols.
    fft_size: tp.ofdm().nfft()
    forward: 'False'
    shift: 'True'
    type: complex
    window: '[]'
  states: {}
- name: carrier_vector_to_stream
  id: blocks_vector_to_stream
  parameters:
    comment: Flatten mapped OFDM carrier vectors for the constellation preview.
    num_items: tp.ofdm().nfft()
    type: complex
  states: {}
- name: constellation_preview
  id: qtgui_const_sink_x
  parameters:
    comment: Mapped MSC, SDC, FAC, pilot, and control carriers before the IFFT.
    grid: 'True'
    gui_hint: 0,0,1,1
    label1: '"DRM carriers"'
    name: '"DRM Carrier Constellation"'
    size: '2048'
    type: complex
  states: {}
- name: cyclic_prefix
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: tp.ofdm().nfft() * tp.ofdm().cp_ratio_enum() // tp.ofdm().cp_ratio_denom()
    input_size: tp.ofdm().nfft()
    tagname: '""'
  states: {}
- name: baseband_gain
  id: blocks_multiply_const_vxx
  parameters:
    comment: Conservative level to protect sound-card outputs from clipping.
    const: '0.01'
    type: complex
  states: {}
- name: baseband_carrier
  id: analog_sig_source_x
  parameters:
    amp: '1.0'
    comment: Shift complex DRM baseband to a 7 kHz real sound-card waveform.
    freq: '7000'
    offset: '0'
    phase: '0'
    samp_rate: '48000'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: baseband_mixer
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: real_output
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: soundcard_sink
  id: audio_sink
  parameters:
    comment: Default 48 kHz output. Select a virtual cable or line output in macOS before running.
    device_name: '""'
    samp_rate: '48000'
  states: {}
- name: spectrum_preview
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: '48000'
    comment: Spectrum of the real 48 kHz waveform sent to the sound card.
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    gui_hint: 0,1,1,1
    label1: '"Sound-card DRM waveform"'
    name: '"DRM Sound-card Spectrum"'
    type: float
    ymax: '0'
    ymin: '-120'
  states: {}

connections:
- [programme_tone, '0', pcm_scale, '0']
- [pcm_scale, '0', audio_encoder, '0']
- [audio_encoder, '0', msc_scrambler, '0']
- [msc_scrambler, '0', msc_mlc, '0']
- [msc_mlc, '0', msc_interleaver, '0']
- [msc_interleaver, '0', cell_mapper, '0']
- [sdc_generator, '0', sdc_scrambler, '0']
- [sdc_scrambler, '0', sdc_mlc, '0']
- [sdc_mlc, '0', cell_mapper, '1']
- [fac_generator, '0', fac_scrambler, '0']
- [fac_scrambler, '0', fac_mlc, '0']
- [fac_mlc, '0', cell_mapper, '2']
- [cell_mapper, '0', ifft, '0']
- [cell_mapper, '0', carrier_vector_to_stream, '0']
- [carrier_vector_to_stream, '0', constellation_preview, '0']
- [ifft, '0', cyclic_prefix, '0']
- [cyclic_prefix, '0', baseband_gain, '0']
- [baseband_gain, '0', baseband_mixer, '0']
- [baseband_carrier, '0', baseband_mixer, '1']
- [baseband_mixer, '0', real_output, '0']
- [real_output, '0', soundcard_sink, '0']
- [real_output, '0', spectrum_preview, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
