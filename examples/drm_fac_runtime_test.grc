options:
  parameters:
    author: HenrydelMal
    category: '[DRM Examples]'
    comment: Runtime compatibility check for the gr-drm FAC generator.
    description: Generates three DRM FAC frames and writes the 216 output bits to drm_fac_output.bin.
    gen_cmake: 'Off'
    generate_options: no_gui
    id: drm_fac_runtime_test
    output_language: python
    run_options: run
    title: DRM FAC Runtime Test
  states: {}

blocks:
- name: tp
  id: variable_drm_config
  parameters:
    RM: '1'
    SO: '3'
    audio_sample_rate: '24000'
    long_interl: 'False'
    msc_mapping: '1'
    msc_prot_level_2_16: '1'
    msc_prot_level_2_64: '0'
    sdc_mapping: '1'
    station_label: '"gr-drm Test"'
    text_message: '"GNU Radio 3.10 compatibility test"'
  states: {}
- name: drm_generate_fac_b_0
  id: drm_generate_fac_b
  parameters:
    tp: tp
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    comment: Stop after three complete FAC frames.
    num_items: tp.fac().L() * 3
    type: byte
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: 'Expected result: 216 bytes containing only binary values 0 and 1.'
    file: '"drm_fac_output.bin"'
    type: byte
    unbuffered: 'True'
  states: {}

connections:
- [drm_generate_fac_b_0, '0', blocks_head_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
